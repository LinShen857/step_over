# Keil uVision project Engineer27.uvprojx, settings and files
target Engineer27 (6240000::V6.24::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Engineer27 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=9 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,DEBUG,EIGEN_NO_IO,LIBXR_DEBUG_BUILD,LIBXR_DEFAULT_SCALAR=double,LIBXR_LOG_LEVEL=4,LIBXR_LOG_OUTPUT_LEVEL=4,LIBXR_SINGLE_CORE=1,LIBXR_SYSTEM_freertos=True,XR_LOG_MESSAGE_MAX_LEN=64,LIBXR_PRINT_ENABLE_ALTERNATE=0,LIBXR_PRINT_ENABLE_EXPLICIT_ARGUMENT_INDEXING=0,LIBXR_PRINT_ENABLE_FLOAT=1,LIBXR_PRINT_ENABLE_INTEGER=1,LIBXR_PRINT_ENABLE_POINTER=0,LIBXR_PRINT_ENABLE_PRECISION=1,LIBXR_PRINT_ENABLE_TEXT=1,LIBXR_PRINT_ENABLE_WIDTH=1,LIBXR_PRINT_FLOAT_ENABLE_DOUBLE=0,LIBXR_PRINT_FLOAT_ENABLE_FIXED=1,LIBXR_PRINT_FLOAT_ENABLE_GENERAL=0,LIBXR_PRINT_FLOAT_ENABLE_LONG_DOUBLE=0,LIBXR_PRINT_FLOAT_ENABLE_SCIENTIFIC=0,LIBXR_PRINT_INTEGER_ENABLE_64BIT=0,LIBXR_PRINT_INTEGER_ENABLE_BASE8_16=1
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/LibXR/src;../Middlewares/Third_Party/LibXR/src/core;../Middlewares/Third_Party/LibXR/src/core/assert;../Middlewares/Third_Party/LibXR/src/core/print;../Middlewares/Third_Party/LibXR/src/core/rw;../Middlewares/Third_Party/LibXR/src/driver;../Middlewares/Third_Party/LibXR/src/driver/usb;../Middlewares/Third_Party/LibXR/src/driver/usb/core;../Middlewares/Third_Party/LibXR/src/driver/usb/device;../Middlewares/Third_Party/LibXR/src/driver/usb/device/bos;../Middlewares/Third_Party/LibXR/src/driver/usb/device/cdc;../Middlewares/Third_Party/LibXR/src/driver/usb/device/dap;../Middlewares/Third_Party/LibXR/src/driver/usb/device/dfu;../Middlewares/Third_Party/LibXR/src/driver/usb/device/gsusb;../Middlewares/Third_Party/LibXR/src/driver/usb/device/hid;../Middlewares/Third_Party/LibXR/src/driver/usb/device/uac;../Middlewares/Third_Party/LibXR/src/middleware;../Middlewares/Third_Party/LibXR/src/middleware/database;../Middlewares/Third_Party/LibXR/src/middleware/logger;../Middlewares/Third_Party/LibXR/src/middleware/message;../Middlewares/Third_Party/LibXR/src/middleware/ramfs;../Middlewares/Third_Party/LibXR/src/middleware/terminal;../Middlewares/Third_Party/LibXR/src/structure;../Middlewares/Third_Party/LibXR/src/structure/queue;../Middlewares/Third_Party/LibXR/src/system;../Middlewares/Third_Party/LibXR/src/utils;../Middlewares/Third_Party/LibXR/driver/st;../Middlewares/Third_Party/LibXR/system/freertos;../Middlewares/Third_Party/LibXR/lib/Eigen;../TOP/Inc;../TOP/Inc/callback;../TOP/Inc/obj;../TOP/Inc/thread;../User
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/RTOS2/Include;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\Engineer27.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c bdma.c crc.c dma.c fdcan.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/App
    ../User/: app_main.cpp
  group Application/User/TOP
    ../TOP/Src/callback/: can_callback.cpp
    ../TOP/Src/thread/: task_chassis.cpp task_daemon.cpp task_error.cpp task_host.cpp task_referee.cpp task_remote_ctrl.cpp task_robo_arm.cpp task_start.cpp task_imu.cpp task_wdg.cpp
  group Middlewares/LibXR/Driver
    ../Middlewares/Third_Party/LibXR/driver/st/: stm32_adc.cpp stm32_adc_gpdma.cpp stm32_atomic_shim.c stm32_can.cpp stm32_canfd.cpp stm32_dac.cpp stm32_flash.cpp stm32_gpio.cpp stm32_i2c.cpp stm32_power.cpp stm32_pwm.cpp stm32_spi.cpp stm32_timebase.cpp stm32_uart.cpp stm32_uart_gpdma.cpp stm32_usb_dev.cpp stm32_usb_ep.cpp stm32_watchdog.cpp
  group Middlewares/LibXR/System
    ../Middlewares/Third_Party/LibXR/system/freertos/: libxr_system.cpp mutex.cpp semaphore.cpp thread.cpp
  group Middlewares/LibXR/Src
    ../Middlewares/Third_Party/LibXR/src/: libxr.cpp
    ../Middlewares/Third_Party/LibXR/src/core/: libxr_mem_cmp.cpp libxr_mem_o3.cpp
    ../Middlewares/Third_Party/LibXR/src/core/print/: writer_runtime.cpp
    ../Middlewares/Third_Party/LibXR/src/core/rw/: read_port.cpp stdio.cpp write_port.cpp write_stream.cpp
    ../Middlewares/Third_Party/LibXR/src/driver/: can.cpp flash.cpp
    ../Middlewares/Third_Party/LibXR/src/driver/usb/core/: desc_cfg.cpp desc_dev.cpp desc_str.cpp ep_pool.cpp
    ../Middlewares/Third_Party/LibXR/src/driver/usb/device/: dev_core.cpp device_class.cpp device_composition.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/database/: raw_sequential.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/: event.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/logger/: logger.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/message/packet/: packet.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/message/: publish.cpp topic.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/message/server/: server.cpp
    ../Middlewares/Third_Party/LibXR/src/middleware/ramfs/: ramfs.cpp
    ../Middlewares/Third_Party/LibXR/src/structure/: double_buffer.cpp list.cpp lockfree_list.cpp
    ../Middlewares/Third_Party/LibXR/src/structure/queue/: mpmc_queue_base.cpp queue_base.cpp
    ../Middlewares/Third_Party/LibXR/src/system/: async.cpp timer.cpp
    ../Middlewares/Third_Party/LibXR/src/utils/: crc_o3.cpp
software components: CMSIS:CORE 6.1.1
